VERSION 5.7 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
MACRO fill10_noPWR
  CLASS PAD SPACER ;
  ORIGIN 0 0 ;
  FOREIGN fill10_noPWR 0 0 ;
  SIZE 10.000 BY 350.000 ;
  SYMMETRY X Y R90 ;
  SITE GF_IO_Site ;
END fill10_noPWR
END LIBRARY
